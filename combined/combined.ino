#include <esp_now.h>
#include <WiFi.h> 
#include "esp_mac.h"
#include <queue>

#include <stdint.h>
#include <stdlib.h>
#include <string.h>

#include "freertos/FreeRTOS.h"
#include "freertos/queue.h"

#define TTLHOPS 5
#define CHANNEL 1
#define TIMETILLOUTOFNET 3 * 1000

#define DEBOUNCE_MS 50

const uint8_t allRecieverMac[6] = {0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
esp_now_peer_info_t broadcastPeer;
uint timeToReset = 0;
volatile uint timeRecievedLastHeartBeat;
uint timeSentLastHeartBeat;
uint timeLastLogged;

// the rgb values of this pod as an originator
int originRed = 0;
int originGreen = 0;
int originBlue = 0;

// the rgb values of message
int messageRed = 0;
int messageGreen = 0;
int messageBlue = 0;

const int redPin = 21;
const int greenPin = 48;
const int bluePin = 47;

const int buttonPin = 2;

enum LED_STATE {INRANGE, OUTOFRANGE, MESSAGE};

volatile LED_STATE currState = INRANGE;

unsigned long lastButtonPress = 0;



/*
Notes:
- Using fixed arrays could be better than all the mallocs and pointers (refactor idea)
- Mention the edge case of no sliding window when transitioning sessions (could also increase sequence number)
- Mention the behavior of higher TTLs being ignored and implications on logging
*/

/*
Merge Guidelines:
- Only increment seq for button presses and delivery reports. To safely increment it (overflow), use get_next_seq()
- process_received_message() must be called in loop() in order to execute propagation and message processing for BUTTON and DELAY_REPORT messages
*/

// -------------------------
// Constants
// -------------------------

#define VERSION 1
#define HAS_RECEIVED_SIZE 10
#define INT_OVERFLOW_BUFFER 10
#define MAC_LIST_CAP 20 // Must be higher than number of ESP's in network!!
#define SEND_LOG_LIST_CAP 20
#define REC_LOG_LIST_CAP 100
#define TTL_START 15
#define RECEIVED_MSG_QUEUE_SIZE 100
#define DELIVERY_REPORT_SEND_NUM 1
#define PROPAGATION_SEND_NUM 2
#define BUTTON_JITTER_LOW_MS 20
#define BUTTON_JITTER_HIGH_MS 100
#define DELIVERY_REPORT_JITTER_LOW_MS 150
#define DELIVERY_REPORT_JITTER_HIGH_MS 500

// -------------------------
// Structures
// -------------------------

// Message types enum
typedef enum {
    HEARTBEAT,          // 0
    BUTTON,             // 1
    DELIVERY_REPORT     // 2
} MessageType;

// Shared structure for all messages
typedef struct __attribute__((packed)) {
    uint8_t ver;                  // Protocol version; reject mismatches
    uint8_t type;                 // 0 = HEARTBEAT, 1 = BUTTON, 2 = DELIVERY_REPORT (optional)
    uint8_t origin[6];            // MAC of the pod that pressed the button (not the last relay)
    uint8_t originalSender[6];    // (Delivery report field) MAC of the pod that originally sent the message
    uint32_t randKey;             // Key generated by ESP on boot, identifies when ESP has turned off/on or had a sequence number overflow
    uint32_t originalRandKey;     // (Delivery report field) randKey of the pod that originally sent the message
    uint16_t seq;                 // Per-origin sequence number, only incremented by sender for signals that will propagate
    uint16_t originalSeq;         // (Delivery report field) seq of the pod that originally sent the message
    uint8_t ttl;                  // Remaining hops until retransmission stops
    uint8_t r, g, b;              // Origin's color
    int8_t rssi;
} msg_t;

// Structure for a (doubly) linked list node, tracking a MAC-identified message source
typedef struct mac_node {
    uint8_t mac[6];                         // Unique MAC address of the message source
    uint32_t randKey;                       // Random key of the message source
    uint32_t lastRandKey;                   // The last random key associated with this message source, to avoid duplicated messages during key transitions

    uint16_t lastReceived;                  // Sequence number of the last message received
    bool hasReceived[HAS_RECEIVED_SIZE];    // Buffer of the last HAS_RECEIVED_SIZE messages (sequence number) below lastReceived and if they have been received ("high" to low sequence number)

    struct mac_node *next;                      // Next node in the linked list
    struct mac_node *prev;                      // Previous node in the linked list
} mac_node_t;

// Structure for a (doubly) linked list of MAC-identified message sources
typedef struct {
    mac_node_t *head;       // Pointer to first node in list, or NULL
    mac_node_t *tail;       // Pointer to last node in list, or NULL

    int size;           // Current number of nodes in the linked list
    int capacity;       // Maximum number of nodes allowed in the linked list
} mac_list_t;

// Structure for a received message log as a (doubly) linked list node
typedef struct rec_node {
    uint8_t origin[6];
    uint32_t randKey;

    uint16_t seq;
    uint8_t hopCount;

    struct rec_node *next;
    struct rec_node *prev;

    int8_t rssi;
} rec_log_t;

// Structure for a sent message recipient as a linked list node
typedef struct sent_rec_node {
    uint8_t mac[6];

    struct sent_rec_node *next;
} send_recipient_t;

// Structure for a sent message log as a (doubly) linked list node
typedef struct sent_node {
    uint32_t randKey;
    uint16_t seq;

    send_recipient_t *recipients_head;

    struct sent_node *next;
    struct sent_node *prev;
} send_log_t;

// Structure for a (doubly) linked list of received message logs
typedef struct {
    rec_log_t *head;
    rec_log_t *tail;

    int size;
    int capacity;
} rec_log_list_t;

// Structure for a (doubly) linked list of sent message logs
typedef struct {
    send_log_t *head;
    send_log_t *tail;

    size_t size;
    size_t capacity;
} send_log_list_t;

// -------------------------
// Global Variables
// -------------------------

mac_list_t macList {
    NULL,
    NULL,
    0,
    MAC_LIST_CAP
};
send_log_list_t sendLogs {
    NULL,
    NULL,
    0,
    SEND_LOG_LIST_CAP
};
rec_log_list_t recLogs {
    NULL,
    NULL,
    0,
    REC_LOG_LIST_CAP
};

uint8_t my_mac[6] = {0, 0, 0, 0, 0, 0}; // MAC address of this ESP32, must be initialized by the program on boot!
uint32_t my_rand_key = 0;
uint16_t my_seq = 0;

QueueHandle_t receivedQueue = NULL;

// -------------------------
// Helper Functions
// -------------------------

// Button message handler
void handle_button_message(msg_t *message) {
    currState = MESSAGE;
    messageRed = message->r;
    messageGreen = message->g;
    messageBlue = message->b;
    timeToReset = millis() + 3000;
}

// Helper to broadcast a message immediately (message argument will be deallocated shortly after return)
void broadcast_message(msg_t *message) {
    esp_now_send(allRecieverMac, (uint8_t *) message, sizeof(msg_t));
}

// PLACEHOLDER: Helper to schedule a message for broadcast at a millis() timestamp (message argument will be deallocated shortly after return)
void schedule_broadcast_message(msg_t *message, unsigned long send_time) {
    return;
}

// Gives a random key between 1 and UINT32_MAX
uint32_t get_rand_key() {
    uint32_t upper = random(0, UINT16_MAX + 1);
    uint32_t lower = random(1, UINT16_MAX + 1);
    return (upper << 16) | lower;
}

// Helper to update and return the new sequence number, accounting for integer overflow
uint16_t get_next_seq() {
    if (my_seq == UINT16_MAX) {
        // Sequence number is about to overflow. Reset it to 0 and get a new random key
        my_rand_key = get_rand_key();
        my_seq = 0;
    } else {
        // Safe from integer overflow. Simply increment the sequence number
        my_seq++;
    }

    return my_seq;
}

// Checks if MAC addresses are identical
bool mac_equal(uint8_t mac1[6], uint8_t mac2[6]){
    for (size_t i = 0; i < 6; i++) {
        if (mac1[i] != mac2[i]) return false;
    }

    return true;
}

// Helper for moving a macList node to the front of the list, maintaining the LRU invariant
void move_mac_to_front(mac_node_t *curr){
    // Return early if curr is NULL or already at the front of the list
    if (!curr || curr == macList.head){
        return;
    }

    // Connect the nodes adjacent to curr to each other (if they exist)
    if (curr->prev) {
        curr->prev->next = curr->next;
    }
    if (curr->next) {
        curr->next->prev = curr->prev;
    }

    // Update list tail if necessary
    if (macList.tail == curr){
        macList.tail = curr->prev;
    }

    // Insert curr at the front of list
    curr->prev = NULL;
    curr->next = macList.head;
    if (macList.head) {
        macList.head->prev = curr;
    }
    macList.head = curr;
}

// Helper for adding a new macList node for the contents of message when the list is full
// New node will replace the reference node and be moved to the front of the list
void update_mac_node(msg_t *message, mac_node_t *node) {
    // Assign the MAC address and randKey of the node, identifies the specific ESP and boot/overflow cycle
    move_mac_to_front(node);
    
    memcpy(node->mac, message->origin, 6);

    node->randKey = message->randKey;
    node->lastRandKey = 0;

    // Reset hasReceived as all false aside from the received sequence number, and reset lastReceived as the sequence number
    memset(node->hasReceived, 0, sizeof(node->hasReceived));
    
    node->hasReceived[0] = true; 

    node->lastReceived = message->seq;
}

// Helper for creating a new macList node for the contents of message and moving it to the front of the list
// Returns a success status that can be optionally used 
bool create_mac_node(msg_t *message){
    // Initialize a new macList node in heap memory
    mac_node_t *new_node = static_cast<mac_node_t *>(malloc(sizeof(mac_node_t)));

    // Check if malloc was successful
    if (!new_node){ 
        // ERROR: Malloc failed
        return false;
    }

    // Assign the MAC address and randKey of the node, identifies the specific ESP and boot/overflow cycle
    memcpy(new_node->mac, message->origin, 6);
    new_node->randKey = message->randKey;
    new_node->lastRandKey = 0;

    // Initialize hasReceived as all false aside from the received sequence number, and initialize lastReceived as the sequence number
    memset(new_node->hasReceived, 0, sizeof(new_node->hasReceived));
    
    new_node->hasReceived[0] = true; 

    new_node->lastReceived = message->seq;

    // Insert new node at the head of macList
    new_node->prev = NULL;
    new_node->next = macList.head;

    if (macList.head) {
        macList.head->prev = new_node;
    }
    macList.head = new_node;

    if (macList.tail == NULL) {
        macList.tail = new_node;
    }

    // Update the size of macList to reflect insertion
    macList.size++;

    return true;
}

void print_mac(const uint8_t mac[6]) {
    Serial.printf("%02X:%02X:%02X:%02X:%02X:%02X:", mac[0], mac[1], mac[2], mac[3], mac[4], mac[5]);
}
void print_rec_log() {
    Serial.println("Printing log (most to least recent):");
    for (rec_log_t *n = recLogs.head; n != NULL; n = n->next) {
        Serial.println("From mac: ");
        print_mac(n->origin);
        Serial.printf("key = %08lx seq=%u hops=%u rssi=%d\n", (unsigned long) n->randKey, (unsigned)n->seq, (unsigned) n->hopCount, n->rssi);
    }
}

// Helper to add a new send log to the sendLogs list and pop the last value of the queue if it is over capacity
void add_send_log(send_log_t *send_log) {
    // Add node to the front of the queue
    if (sendLogs.head) {
        sendLogs.head->prev = send_log;
    }
    send_log->next = sendLogs.head;
    send_log->prev = NULL;
    sendLogs.head = send_log;

    // Set tail if necessary
    if (!sendLogs.tail) {
        sendLogs.tail = send_log;
    }

    // Check for queue over capacity
    while (sendLogs.size >= sendLogs.capacity) {
        // Remove the tail of the queue
        if (!sendLogs.tail) {
            // ERROR: Nothing to remove
            break;
        }

        if (sendLogs.tail->prev) {
            sendLogs.tail->prev->next = NULL;
            send_log_t *tmp = sendLogs.tail;
            sendLogs.tail = sendLogs.tail->prev;

            send_recipient_t *recipient = tmp->recipients_head;

            while (recipient != NULL) {
                send_recipient_t *next = recipient->next;
                free(recipient);
                recipient = next;
            }

            free(tmp);
        } else {
            send_recipient_t *recipient = sendLogs.tail->recipients_head;

            while (recipient != NULL) {
                send_recipient_t *next = recipient->next;
                free(recipient);
                recipient = next;
            }

            free(sendLogs.tail);
            sendLogs.head = NULL;
            sendLogs.tail = NULL;
        }

        sendLogs.size--;
    }

    // Update size
    sendLogs.size++;
}

// *** MIGHT NEED TO FIX** (2.E)
// Helper to update a send log (add a new recipient) for a new DELIVERY_REPORT
void update_send_log(msg_t *message) {
    // Find the sent message log based on randKey and seq
    send_log_t *curr = sendLogs.head;

    while (curr) {
        if (curr->randKey == message->originalRandKey && curr->seq == message->originalSeq) {
            send_recipient_t *recipient = curr->recipients_head;

            while (recipient != NULL) {
                if (mac_equal(recipient->mac, message->origin)) {
                    return;
                }
                recipient = recipient->next;
            }
            
            // A sent message log already exists for this message, add the recipient
            send_recipient_t *new_recipient = static_cast<send_recipient_t *>(malloc(sizeof(send_recipient_t)));

            // Check if malloc was successful
            if (!new_recipient){ 
                // ERROR: Malloc failed
                return;
            }

            // Add the correct MAC address to the node
            memcpy(new_recipient->mac, message->origin, 6);

            // Put the node at the head of the linked list
            new_recipient->next = curr->recipients_head;
            curr->recipients_head = new_recipient;

            return;
        }

        curr = curr->next;
    }

    // The send message log was not found, create a new one and add it to the list
    send_log_t *new_send_log = static_cast<send_log_t *>(malloc(sizeof(send_log_t)));

    // Check if malloc was successful
    if (!new_send_log){ 
        // ERROR: Malloc failed
        return;
    }

    // Instantiate randKey and seq
    new_send_log->randKey = message->originalRandKey;
    new_send_log->seq = message->originalSeq;
    new_send_log->recipients_head = NULL;

    // Instantiate the send recipients with this new send recipient
    send_recipient_t *new_recipient = static_cast<send_recipient_t *>(malloc(sizeof(send_recipient_t)));

    // Check if malloc was successful
    if (!new_recipient){ 
        // ERROR: Malloc failed
        free(new_send_log);
        return;
    }

    // Add the correct MAC address to the node
    memcpy(new_recipient->mac, message->origin, 6);

    // Put the node at the head of the linked list
    new_recipient->next = new_send_log->recipients_head;
    new_send_log->recipients_head = new_recipient;

    // Add the send log to the sendLogs list
    add_send_log(new_send_log);
}

// Helper to add a new message reception log to the recLogs list and pop the last value of the queue if it is over capacity
void add_rec_log(msg_t *message) {
    // The send message log was not found, create a new one and add it to the list
    rec_log_t *new_rec_log = static_cast<rec_log_t *>(malloc(sizeof(rec_log_t)));

    // Check if malloc was successful
    if (!new_rec_log){ 
        // ERROR: Malloc failed
        return;
    }

    // Instantiate origin, randKey, and seq
    memcpy(new_rec_log->origin, message->origin, 6);
    new_rec_log->randKey = message->randKey;
    new_rec_log->seq = message->seq;

    // Instantiate hop count
    new_rec_log->hopCount = TTL_START - message->ttl + 1;

    // Add node to the front of the queue
    if (recLogs.head) {
        recLogs.head->prev = new_rec_log;
    }
    new_rec_log->next = recLogs.head;
    new_rec_log->prev = NULL;
    new_rec_log->rssi = message->rssi;
    recLogs.head = new_rec_log;

    // Set tail if necessary
    if (!recLogs.tail) {
        recLogs.tail = new_rec_log;
    }

    // Check for queue over capacity
    while (recLogs.size >= recLogs.capacity) {
        // Remove the tail of the queue
        if (!recLogs.tail) {
            // ERROR: Nothing to remove
            break;
        }

        if (recLogs.tail->prev) {
            recLogs.tail->prev->next = NULL;
            rec_log_t *tmp = recLogs.tail;
            recLogs.tail = recLogs.tail->prev;
            free(tmp);
        } else {
            free(recLogs.tail);
            recLogs.head = NULL;
            recLogs.tail = NULL;
        }

        recLogs.size--;
    }

    // Update size
    recLogs.size++;
}

void send_delivery_report(msg_t *message) {
    msg_t delivery_report {};

    delivery_report.ver = VERSION;
    delivery_report.type = DELIVERY_REPORT;
    memcpy(delivery_report.origin, my_mac, 6);
    memcpy(delivery_report.originalSender, message->origin, 6);
    delivery_report.originalRandKey = message->randKey;

    // Must update randKey after seq, in case seq update causes randKey to change
    delivery_report.seq = get_next_seq();
    delivery_report.randKey = my_rand_key;

    delivery_report.originalSeq = message->seq;
    delivery_report.ttl = TTL_START;

    /*
    Holdover from scheduling redundancy:

    // Schedule attempts of the delivery report broadcast
    unsigned long base_time = millis();

    for (size_t i = 0; i < DELIVERY_REPORT_SEND_NUM; i++) {
        unsigned long send_time = base_time + random(DELIVERY_REPORT_JITTER_LOW_MS, DELIVERY_REPORT_JITTER_HIGH_MS + 1);
        schedule_broadcast_message(&delivery_report, send_time);
        base_time += DELIVERY_REPORT_JITTER_HIGH_MS;
    }
    */

    // Send delivery report immediately
    broadcast_message(&delivery_report);
}

// Helper function to construct the propagated message (decrement TTL) and broadcast it
void exec_message_prop(msg_t *message) {
    msg_t propagated_message;

    // Copy all fields of the received message into the to-be-propagated message
    memcpy(&propagated_message, message, sizeof(msg_t));

    // Decrement TTL
    propagated_message.ttl--;

    /*
    Holdover from scheduling redundancy:

    // Schedule attempts of the propagation broadcast
    unsigned long base_time = millis();

    bool is_button = message->type == BUTTON;

    size_t send_num = is_button ? PROPAGATION_SEND_NUM : DELIVERY_REPORT_SEND_NUM;

    long jitter_low = is_button ? BUTTON_JITTER_LOW_MS : DELIVERY_REPORT_JITTER_LOW_MS;

    long jitter_high = is_button ? BUTTON_JITTER_HIGH_MS : DELIVERY_REPORT_JITTER_HIGH_MS;

    for (size_t i = 0; i < send_num; i++) {
        unsigned long send_time = base_time + random(jitter_low, jitter_high + 1);
        schedule_broadcast_message(&propagated_message, send_time);
        base_time += jitter_high;
    }
    */

     // Send propagated message immediately
    broadcast_message(&propagated_message);
}

// Helper to be called by handle_message_prop() when message is BUTTON or DELIVERY_REPORT type and has yet to be received
// Must execute the procedure called for by the message, particularly LED control for BUTTON messages
// Must update local logs according to the message
// Must create and send a delivery report, if necessary
// Must propagate the message, contingent on updated TTL and originalSender for DELIVERY_REPORT type
void process_message_prop(msg_t *message) {
    // If message is of type BUTTON, execute the procedure associated with button messages
    if (message->type == BUTTON) {
        handle_button_message(message);
    }

    // Update local logs for the message
    if (message->type == BUTTON) {
        // Log should be added to the recLogs
        add_rec_log(message);
    } else if (message->type == DELIVERY_REPORT) {
        // Only add a log if it was meant for this MAC address
        if (mac_equal(message->originalSender, my_mac)) {
            update_send_log(message);
            // No work is left for the completed delivery report (will not be propagated), so return early
            return;
        }
    }

    // Send a delivery report, if necessary
    if (message->type == BUTTON) {
        send_delivery_report(message);
    }

    // Update the TTL and propagate the message, if necessary
    if (message->ttl > 0) {
        exec_message_prop(message);
    }
}

// Handles the propagation of a message, whether it is BUTTON or DELIVERY_REPORT type
void handle_message_prop(msg_t *message) {
    // Check if MAC address of message is already registered in macList
    mac_node_t *curr = macList.head;
    
    while (curr) {
        // Check if received MAC matches current node MAC
        if (mac_equal(message->origin, curr->mac)){
            // Received MAC matches, check if the randKey matches
            // If randKey does not match, the sender has likely rebooted or overflown since last received message, so we need to reset tracking
            if (message->randKey == curr->randKey){
                // Sender node likely hasn't rebooted nor overflown since last received message

                // Sequence number can be trusted to identify "order" of messages. Use to determine if message should propagate or not
                if (message->seq > curr->lastReceived){
                    // This is definitely a message we have not received yet
                    // We must shift hasReceived and update lastReceived

                    // Shift hasReceived to track entries of sequence numbers [message->seq - HAS_RECEIVED_SIZE + 1, message->seq]
                    size_t diff = message->seq - curr->lastReceived;

                    if (diff >= HAS_RECEIVED_SIZE) {
                        // None of the old hasReceived members will be in the shifted arary
                        // Clear the old hasReceived array

                        memset(curr->hasReceived, 0, sizeof(curr->hasReceived));
                    } else {
                        // Some of the old hasReceived members will be in the shifted array
                        // Shift hasReceived array by diff positions
                        for (size_t i = HAS_RECEIVED_SIZE - 1; i >= (int)diff; --i) {
                            curr->hasReceived[i] = curr->hasReceived[i - diff];
                        }
                        // Clear all values newer than the shifted ones
                        for (size_t i = 0; i < diff; ++i) {
                            curr->hasReceived[i] = false;
                        }
                    }

                    // Set the first entry of the array (message that we just received)
                    curr->hasReceived[0] = true;
                    // Update lastReceived with the new, higher sequence number
                    curr->lastReceived = message->seq;

                    // Move node to the front of the LRU macList (most recent received message)
                    move_mac_to_front(curr);

                    // Process and propagate the message
                    process_message_prop(message);
                } else if (curr->lastReceived - message->seq < HAS_RECEIVED_SIZE) {
                    // The sequence number falls within the bounds of hasReceived
                    // We must check the array to see if it has been received already
                    size_t pos = curr->lastReceived - message->seq;

                    if (!curr->hasReceived[pos]) {
                        // Message has not been received yet
                        curr->hasReceived[pos] = true;

                        // Move node to the front of the LRU macList (most recent received message)
                        move_mac_to_front(curr);

                        // Process and propagate the message
                        process_message_prop(message);
                    }
                }
                // In all other cases, we very likely have already received the message, as it is lower than the current sequence number and
                // outside the range of hasReceived (and the sequence number has very likely not reset)
            } else if (message->randKey != curr->lastRandKey) {
                // randKey does not match and this is not a stale message from the old randKey. The sender has likely rebooted or overflown 
                // since last received message, so we need to reset tracking
                // This counts as a new, yet-to-be received message
                // Udpate randKey
                curr->lastRandKey = curr->randKey;
                curr->randKey = message->randKey;

                // Move node to the front of the LRU macList (most recent received message)
                move_mac_to_front(curr);

                // Update lastReceived and reset hasReceived
                memset(curr->hasReceived, 0, sizeof(curr->hasReceived));

                curr->hasReceived[0] = true; 

                curr->lastReceived = message->seq;

                // Process and propagate the message
                process_message_prop(message);
            }

            // Found MAC address, checked if we had received it before, and processed/propagagated if necessary. Good to return
            return;
        }

        // Haven't seen MAC address before, so keep searching
        curr = curr->next;
    }

    // We have never received a message for this MAC address before. We must either create a new node for it or replace the least-recently-used node if macList is full
    if (macList.size >= macList.capacity) {
        // macList is full, so we must replace the least-recently-used node with this node, and move it to the front
        mac_node_t *node = macList.tail;

        if (!node) {
            // ERROR: macList is at capacity, but empty
            return;
        }

        update_mac_node(message, node);

        // Process and propagate the message
        process_message_prop(message);
    } else {
        // macList is not full, so we must create a new MAC node for this new address and add it to the front of th elist
        if (!create_mac_node(message)) {
            return;
        }

        // Process and propagate the message
        process_message_prop(message);
    }
}

// Helper to process a received message from receivedQueue (message at head) and remove it from the queue
// Returns if a message was actually processed or not (if receivedQueue has elements or not)
bool process_received_buffer_msg() {
    // Try to received message from queue
    msg_t message;

    if (xQueueReceive(receivedQueue, &message, 0) == pdTRUE) {
        handle_message_prop(&message);
        return true;
    }

    // There were no messages in the queue
    return false;
}

void heartbeat()
{
  msg_t heartBeat = {};
  heartBeat.type = 0;
  WiFi.macAddress(heartBeat.origin);
  heartBeat.ttl = 0;
  heartBeat.ver = 1;

  esp_now_send(allRecieverMac, (uint8_t *) &heartBeat, sizeof(heartBeat));
}

void OnDataRecv(const esp_now_recv_info_t *info, const uint8_t *incomingData, int len)
{
  if (len != sizeof(msg_t)) return; //throw out garbage packets
  if(info->rx_ctrl->rssi < -75) return;

    msg_t message;
    memcpy(&message, incomingData, sizeof(message));
    message.rssi = info->rx_ctrl->rssi;

    // Reject messages that are incorrect version
    if (message.ver != VERSION) {
        return;
    }

    // Reject messages that this node sent
    if (mac_equal(message.origin, my_mac)) {
        return;
    }

    // Check if message need to be propagated (added to the queue)
    if (message.type == BUTTON || message.type == DELIVERY_REPORT) {
        xQueueSend(receivedQueue, &message, 0);
    } else if (message.type == HEARTBEAT) {
        timeRecievedLastHeartBeat = millis();
        if (currState != MESSAGE) {
            currState = INRANGE;
        }  
    }
}

void declareBroadcastPeer()
{
  memcpy(broadcastPeer.peer_addr, allRecieverMac, 6);
  broadcastPeer.ifidx=WIFI_IF_STA;
  broadcastPeer.channel = CHANNEL;
  broadcastPeer.encrypt = false;
  if (esp_now_add_peer(&broadcastPeer) != ESP_OK){
    Serial.println("Failed to add peer");
    return;
  }
}

void rgbFromMAC() {
  originRed = (int)(my_mac[3] * 41) % 256;
  originGreen = (int)(my_mac[4] * 41) % 256;
  originBlue = (int)(my_mac[5] * 41) % 256;
  Serial.println(originRed);
  Serial.println(originGreen);
  Serial.println(originBlue);
}

void setColor(int r, int g, int b) {
  analogWrite(redPin, r);
  analogWrite(greenPin, g);
  analogWrite(bluePin, b);
}

void send_button_press(){
    if (millis() - lastButtonPress < DEBOUNCE_MS) {
        return;
    }

    //Initialize struct where all NULL fields equal 0
    msg_t msg {};
    msg.ver = VERSION;
    msg.type = BUTTON;
    //arrays can't be assigned
    memcpy(msg.origin, my_mac, 6);
    msg.seq = get_next_seq();
    msg.randKey = my_rand_key;
    msg.ttl = TTL_START;
    msg.r = originRed; msg.b = originBlue; msg.g = originGreen;

    currState = MESSAGE;
    messageRed = msg.r;
    messageBlue = msg.b;
    messageGreen = msg.g;

    // Send button message
    /*
     unsigned long base_time = millis();
    for (int i = 0; i < PROPAGATION_SEND_NUM; i++){
        unsigned long send_time = base_time + random(BUTTON_JITTER_LOW_MS, BUTTON_JITTER_HIGH_MS + 1);
        schedule_broadcast_message(&msg, send_time);
        base_time += BUTTON_JITTER_HIGH_MS;
    }
    */

    broadcast_message(&msg);

    lastButtonPress = millis();
}


void setup() {
  // put your setup code here, to run once:
  Serial.begin(115200);

  Serial.println("Starting program");

  receivedQueue = xQueueCreate(RECEIVED_MSG_QUEUE_SIZE, sizeof(msg_t));

  if (receivedQueue == NULL) {
    // ERROR: receivedQueue could not be instantiated
    abort();
  }

  WiFi.mode(WIFI_MODE_STA);
  my_rand_key = get_rand_key();
  esp_read_mac(my_mac, ESP_MAC_WIFI_STA);
  if (esp_now_init() != ESP_OK) 
    {
      Serial.println("Error initializing ESP-NOW");
      return;
    }
  esp_now_register_recv_cb(OnDataRecv); //tell esp which function to run on packet recieve.

  timeRecievedLastHeartBeat = millis();
  timeSentLastHeartBeat = millis();
  
  declareBroadcastPeer();

  rgbFromMAC();

  pinMode(redPin, OUTPUT);
  pinMode(greenPin, OUTPUT);
  pinMode(bluePin, OUTPUT);

  pinMode(buttonPin, INPUT_PULLUP); 
  attachInterrupt(digitalPinToInterrupt(buttonPin), send_button_press, FALLING);
}

void loop() {
  process_received_buffer_msg();

  // send heartbeat 
  if(millis()-timeRecievedLastHeartBeat > TIMETILLOUTOFNET && currState != MESSAGE)
  {
    currState = OUTOFRANGE;
  }
  //check if we need to send heartbeat
  if(millis()-timeSentLastHeartBeat > 500)
  {
    heartbeat();
    timeSentLastHeartBeat = millis();
  }

  if (Serial.available()) {
    char c = Serial.read();
    if (c == 'p') print_rec_log();
  }

  if (currState == INRANGE) {
    setColor(0, 255, 0);
    // look for incoming messages from queue here (if nonempty). Otherwise, become OUTOFRANGE.
  } else if (currState == OUTOFRANGE) {
    setColor(255, 0, 0);
    // look for heartbeat here
    
  } else if (currState == MESSAGE) {
    // determine color of incoming message rgb (blue for now)
    // If a second button is received, the LED instantly changes to this new button color
    // Button receptions are not stored in a queue/guarantees to display for timeToReset mS
    setColor(messageRed, messageGreen, messageBlue);
    if (millis() >= timeToReset) {
        currState = INRANGE;
    }
  }
}
